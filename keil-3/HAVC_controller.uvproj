# Keil uVision project HAVC_controller.uvproj, settings and files
target Target 1 (MCS-51)
  device: AX11005 ASIX Electronics Corporation
  cpu: IRAM(0-0xFF) CLOCK(100000000) MOD_CONT MODDA MODDP2 XRAM (0xF000-0xFFFF)
  output: HAVC_controller +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
